# Repository RedBirdRacing/ee_sw_2025

## KiCad design accum_pcb_under/accum_pcb_under.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_4.3mm_M4
J1_1, J1_2, J2_1, J2_2, J3_1, J3_2, J4_1, J4_2, J5_1, J5_2, J6_1, J6_2, J7_1, J7_2, J8_1, J8_2: Conn_01x01_Pin; PinHeader_1x01_P2.00mm_Vertical
J9: Conn_02x08_Top_Bottom; Molex_Micro-Fit_3.0_43045-1612_2x08_P3.00mm_Vertical

Connections:
/temp_1_1: J1_1.1, J9.8
/temp_1_2: J1_2.1, J9.7
/temp_2_1: J2_1.1, J9.16
/temp_2_2: J2_2.1, J9.15
/temp_3_1: J3_1.1, J9.6
/temp_3_2: J3_2.1, J9.5
/temp_4_1: J4_1.1, J9.1
/temp_4_2: J4_2.1, J9.2
/temp_5_1: J5_1.1, J9.9
/temp_5_2: J5_2.1, J9.10
/temp_6_1: J6_1.1, J9.4
/temp_6_2: J6_2.1, J9.3
/temp_7_1: J7_1.1, J9.14
/temp_7_2: J7_2.1, J9.13
/temp_8_1: J8_1.1, J9.12
/temp_8_2: J8_2.1, J9.11

Board: 2 copper layers, 447.5 x 66.9 mm, 21 parts (0 on the bottom side), 16 nets.

## KiCad design accum_pcb_up/accum_pcb_up.kicad_pcb

Parts:
F1, F2, F3, F4, F5, F6, F7, F8, F9, F10, F11, F12, F13, F14, F15, F16, F17, F18, F19, F20, F21, F22, F23: Fuse; Fuse_Littelfuse-NANO2-885
H1, H2, H3, H4: MountingHole; MountingHole_4.3mm_M4
J1: Conn_02x12_Top_Bottom; Molex_Micro-Fit_3.0_43045-2412_2x12_P3.00mm_Vertical

Connections:
/Cell_1+: F1.1
/Cell_1+_out: F1.2, J1.3
/Cell_1-: F2.1
/Cell_1-_out: F2.2, J1.8
/Cell_2-: F3.1
/Cell_2-_out: F3.2, J1.5
/Cell_3-: F4.1
/Cell_3-_out: F4.2, J1.7
/Cell_4-: F5.1
/Cell_4-_out: F5.2, J1.4
/Cell_5-: F6.1
/Cell_5-_out: F6.2, J1.10
/Cell_6-: F7.1
/Cell_6-_out: F7.2, J1.6
/Cell_7-: F8.1
/Cell_7-_out: F8.2, J1.9
/Cell_8-: F9.1
/Cell_8-_out: F9.2, J1.18
/Cell_9-: F10.1
/Cell_9-_out: F10.2, J1.21
/Cell_10-: F11.1
/Cell_10-_out: F11.2, J1.15
/Cell_11-: F12.1
/Cell_11-_out: F12.2, J1.20
/Cell_12-: F13.1
/Cell_12-_out: F13.2, J1.16
/Cell_13-: F14.1
/Cell_13-_out: F14.2, J1.19
/Cell_14-: F15.1
/Cell_14-_out: F15.2, J1.17
/Cell_15-: F16.1
/Cell_15-_out: F16.2, J1.11
/Cell_16-: F17.1
/Cell_16-_out: F17.2, J1.2
/Cell_17-: F18.1
/Cell_17-_out: F18.2, J1.12
/Cell_18-: F19.1
/Cell_18-_out: F19.2, J1.14
/Cell_19-: F20.1
/Cell_19-_out: F20.2, J1.23
/Cell_20-: F21.1
/Cell_20-_out: F21.2, J1.1
/Cell_21-: F22.2
/Cell_21-_out: F22.1, J1.24
/Cell_22-: F23.2
/Cell_22-_out: F23.1, J1.13

Board: 2 copper layers, 447.5 x 66.9 mm, 28 parts (0 on the bottom side), 23 nets.

## KiCad design kicad/BDU_LVS/BDU_LVS.kicad_pcb

Parts:
C1: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder_L
D1, D2, D3, D4: LED; LED_0805_2012Metric_Pad1.45x1.40mm_HandSolder
H2, H3, H5, H6: MountingHole; MountingHole_4.3mm_M4
J1, J2, J3: Relay connector; Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical
J4: Conn_01x02; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J16: DCDC; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J17: AMS; Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical
J18: TSAL_G; Molex_Micro-Fit_3.0_43650-0415_1x04_P3.00mm_Vertical
K1, K2, K3: Relay_DPST-NO
R2, R3, R4, R5, R10, R11, R12, R13: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder_L
R6, R7, R8, R9: 4k7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder_L
U1: LTV-847S; SMDIP-16_W9.53mm

Connections:
+12V: C1.1, J1.3, J2.3, J3.3, J4.2, K1.23, K2.23, K3.23, U1.10, U1.12, U1.14, U1.16
/high_aux: J3.4, K2.24, R2.1
/high_out: R6.1, R13.1, U1.15
/low_aux: J2.4, K3.24, R3.1
/low_out: R7.1, R12.1, U1.11
/pre_aux: J1.4, K1.24, R4.1
/pre_out: J16.2, R8.1, R11.1, U1.13
/sdc_out: R9.1, R10.1, U1.9
AIR_H-: J3.1, J17.1, J18.1, K2.A1
AIR_L-: J2.1, J17.2, J18.2, K3.A1
GND: C1.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), J4.1, J16.1, R6.2, R7.2, R8.2, R9.2, U1.2, U1.4, U1.6, U1.8
unnamed: D1.2 (A), R10.2
unnamed: D2.2 (A), R11.2
unnamed: D3.2 (A), R12.2
unnamed: D4.2 (A), R13.2
unnamed: K1.13, K2.13
unnamed: R2.2, U1.1
unnamed: R3.2, U1.5
unnamed: R4.2, U1.3
unnamed: R5.2, U1.7
PRE-: J1.1, J17.3, J18.3, K1.A1
SDC+: J1.2, J2.2, J3.2, J17.4, J18.4, K1.A2, K2.A2, K3.A2, R5.1

Notes on the sheet:
上述电压检测必须在相应的驱动系统的外壳内部进行。

Board: 2 copper layers, 67.0 x 60.0 mm, 29 parts (1 on the bottom side), 21 nets.

## KiCad design kicad/BDU_TS/BDU_TS.kicad_pcb

Board: 2 copper layers, 83.7 x 60.0 mm, 16 parts (0 on the bottom side), 5 nets.

Parts:
F2, F10: Fuse; Fuse_Littelfuse-NANO2-885
H1, H2, H4, H5: MountingHole; MountingHole_4.3mm_M4
J5: IMD+; Molex_Micro-Fit_3.0_43650-0200_1x02_P3.00mm_Horizontal
J6: Voltmeter+; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J7: TSAL_green+; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J8: AIR+; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J9: TSAL_green-; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J10: Voltmeter-; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J11: IMD-; Molex_Micro-Fit_3.0_43650-0200_1x02_P3.00mm_Horizontal
J12: AIR-; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J13: PRE+; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
R1: 3K9; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical

Connections:
/fused_TS+: F10.1, J5.1, J5.2, J6.1, J6.2, J7.1, J7.2
/precharge: F2.1, J13.1, J13.2
unnamed: F2.2, R1.1
TS+: F10.2, J8.1, J8.2, R1.2
TS-: J9.1, J9.2, J10.1, J10.2, J11.1, J11.2, J12.1, J12.2

## KiCad design kicad/DSCHG_TSMP_v1.0/DSCHG_TSMP.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_4.3mm_M4
J1: TSMP-; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J2: Dis_Relay-; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J3: TSMP+; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J5: Dis_Relay+; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J6: HV-; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J7: HV+; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J8: SDC+; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J9: SDC+&Relay_GND; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J10: R+; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J11: R-; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J12: Relay_GND; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J13: TSAL_TS-; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
J14: TSAL_TS+; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical
R1, R2: R; TO-220-2_Vertical

Connections:
unnamed: J1.1, J1.2, R1.2
unnamed: J3.1, J3.2, R2.2
unnamed: J8.1, J8.2, J9.1
unnamed: J7.1, J7.2, J10.1, J10.2, J14.1, J14.2, R2.1
unnamed: J5.1, J5.2, J11.1, J11.2
unnamed: J9.2, J12.1, J12.2
unnamed: J2.1, J2.2, J6.1, J6.2, J13.1, J13.2, R1.1

Board: 2 copper layers, 100.0 x 50.0 mm, 19 parts (0 on the bottom side), 7 nets.

## KiCad design kicad/Frame_PCB/V0-UmbilicalBoard.kicad_pcb

Parts:
H1, H2: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J1: Conn_02x08_Odd_Even; Molex_Micro-Fit_3.0_43045-1412_2x07_P3.00mm_Vertical
J2: Motor; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J3: Hotend Fan; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4: Part Cooling Fan; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J5: Heater; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
J6: Thermistor; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J7: X-Endstop; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical

Connections:
/A1: J1.1, J2.1
/A2: J1.2, J2.2
/B1: J1.3, J2.3
/B2: J1.4, J2.4
/Hotend_Fan+: J1.12, J3.2
/Hotend_Fan-: J1.11, J3.1
/PartFan+: J1.9, J4.1
/PartFan-: J1.10, J4.2
GND: H1.1, H2.1
unnamed: J1.5, J7.1
unnamed: J1.6, J5.2
unnamed: J1.7, J5.1
unnamed: J1.8, J7.2
unnamed: J1.13, J6.2
unnamed: J1.14, J6.1

Board: 2 copper layers, 63.0 x 20.0 mm, 9 parts (0 on the bottom side), 15 nets.

## KiCad design kicad/Indicators v1.05/Indicators.kicad_pcb

Board: 2 copper layers, 58.0 x 31.0 mm, 21 parts (0 on the bottom side), 10 nets.

Parts:
1M: 1M; R_0805_2012Metric
1k, 1k#2, 1k#3: 1k; R_0805_2012Metric
C1: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2: LED; LED_D5.0mm
D3, D5: D; D_SMA_Handsoldering
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x04_Socket; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J2: Conn_01x03_Socket; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J3: Hazzard button; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4: Left signal; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J5: Conn_01x02_Socket; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J6: Right signal; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
NE555: NE555P; DIP-8_W7.62mm

Connections:
+12V: 1k#2.1, C2.2, J5.2, NE555.4 (R), NE555.8 (VCC)
Dash_Hazard: D3.2 (A), D5.2 (A), J1.3, J3.1
Dash_left: D1.2 (A), D3.1 (K), J1.4, J2.1, J4.2
Dash_right: D2.2 (A), D5.1 (K), J1.2, J2.3, J6.2
GND: 1k.2, 1k#3.2, C1.2, C2.1, J1.1, J4.1, J5.1, J6.1, NE555.1 (GND), NE555.5 (CV)
unnamed: 1k.1, D1.1 (K)
unnamed: 1k#3.1, D2.1 (K)
unnamed: 1M.2, 1k#2.2, NE555.7 (DIS)
unnamed: 1M.1, C1.1, NE555.2 (TR), NE555.6 (THR)
Trigger: J2.2, J3.2, NE555.3 (Q)
